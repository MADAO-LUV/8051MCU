# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Nixie.c Nixie.h Key.c Key.h Delay.c Delay.h Timer1.h Timer1.c Timer0.h Timer0.c IR.h IR.c Int0.h Int0.c Motor.c
